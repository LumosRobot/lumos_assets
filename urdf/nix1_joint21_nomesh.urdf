Commit message: update nix1 torso link collision

File: urdf/nix1_joint21_nomesh.urdf (robot description, URDF)
Before this commit: robot nix1, 22 links, 21 joints
Links:
- link torso_link: geometry collision box size=0.019 0.108 0.019; collision box size=0.164 0.149 0.248
